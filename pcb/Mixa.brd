# Repository mariosgit/mbMixa

File README.md:

# mb'Mixa

Simple stereo mixer for eurorack.

## Status

Not tested, alpha phase !!!

## Features:
* 6 channels
* -oo .... +12dB gain.
* When right channel is unconnected, the left will be normalized to both channels.
* Want a stereo AUX in ? You can put a true stereo jack (green PM301cm) on the right jack position and leave the left unpopulated. (Channels are twisted then :( mhm might change later.. ))

## BOM

https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=f7be203a88 

### Jacks

Watch out for the thin leads, 2 underneath one at the side pointing down.

From Cina or UK: https://www.thonk.co.uk/shop/3-5mm-jacks/
* Stereo sometimes called PJ366ST
* Mono "THONKICONN" or PJ301CM?

## EAGLE design pcb/Mixa.brd

Parts:
ATT_0, ATT_2, ATT_3, ATT_4, ATT_5: 20k; TT_2TAP_VERTICAL
ATT_1: 20k; TT_2TAP_VERTICAL; MOUSER 688-RK09L12D0A1W
C5: 100p; C0603; MOUSER 710-885012206077
C6: 100p; C0603
IN1L0, IN1L1, IN1L2, IN1L3, IN1L4, IN1L5, IN1R0, IN1R1, IN1R2, IN1R3, IN1R4, IN1R5: PJ301_THONKICONN6; WQP_PJ_301M6
OPAMP_IS: TL074D; SO14; MOUSER 595-TL074IDR
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R15, R16: 22k; R0603
R14: 22k; R0603; MOUSER 667-ERJ-3RBD2202V
R17: 100; R0603; MOUSER 710-885012109014
R18: 100k; R0603; MOUSER 667-ERJ-3RBD104V
R19: 100; R0603
R20: 100k; R0603
SEND_L: PJ301_THONKICONN6; WQP_PJ_301M6
SEND_LR: PJ301_THONKICONN6; WQP_PJ_301M6
SEND_R: PJ301_THONKICONN6; WQP_PJ_301M6

Connections:
BUS_L: OPAMP_IS.6 (-IN), R1.2, R3.2, R5.2, R7.2, R9.2, R11.2, R13.1
BUS_R: OPAMP_IS.2 (-IN), R2.2, R4.2, R6.2, R8.2, R10.2, R12.2, R14.1
GND: ATT_0.CCW, ATT_0.CCW1, ATT_1.CCW, ATT_1.CCW1, ATT_2.CCW, ATT_2.CCW1, ATT_3.CCW, ATT_3.CCW1, ATT_4.CCW, ATT_4.CCW1, ATT_5.CCW, ATT_5.CCW1, IN1L0.P1 (1), IN1L1.P1 (1), IN1L2.P1 (1), IN1L3.P1 (1), IN1L4.P1 (1), IN1L5.P1 (1), IN1R0.P1 (1), IN1R1.P1 (1), IN1R2.P1 (1), IN1R3.P1 (1), IN1R4.P1 (1), IN1R5.P1 (1), OPAMP_IS.3 (+IN), OPAMP_IS.5 (+IN), OPAMP_IS.10 (+IN), OPAMP_IS.12 (+IN), SEND_L.P1 (1), SEND_LR.P1 (1), SEND_R.P1 (1); also elsewhere on the board
unnamed: ATT_0.CW, IN1L0.P3 (3), IN1R0.P2 (2)
unnamed: ATT_0.CW1, IN1R0.P3 (3)
unnamed: ATT_0.CENTER, R1.1
unnamed: ATT_0.CENTER1, R2.1
unnamed: ATT_1.CW, IN1L1.P3 (3), IN1R1.P2 (2)
unnamed: ATT_1.CW1, IN1R1.P3 (3)
unnamed: C5.2, OPAMP_IS.9 (-IN), R15.2, R18.1
unnamed: ATT_1.CENTER, R3.1
unnamed: ATT_1.CENTER1, R4.1
unnamed: ATT_2.CW, IN1L2.P3 (3), IN1R2.P2 (2)
unnamed: ATT_2.CW1, IN1R2.P3 (3)
unnamed: C6.2, OPAMP_IS.13 (-IN), R16.2, R20.1
unnamed: ATT_2.CENTER, R5.1
unnamed: ATT_2.CENTER1, R6.1
unnamed: R17.1, SEND_L.P3 (3), SEND_LR.P3 (3)
unnamed: ATT_3.CW, IN1L3.P3 (3), IN1R3.P2 (2)
unnamed: ATT_3.CW1, IN1R3.P3 (3)
unnamed: ATT_3.CENTER, R7.1
unnamed: ATT_3.CENTER1, R8.1
unnamed: ATT_4.CW, IN1L4.P3 (3), IN1R4.P2 (2)
unnamed: R19.1, SEND_LR.P2 (2), SEND_R.P3 (3)
unnamed: ATT_4.CW1, IN1R4.P3 (3)
unnamed: ATT_4.CENTER, R9.1
unnamed: ATT_4.CENTER1, R10.1
unnamed: ATT_5.CW, IN1L5.P3 (3), IN1R5.P2 (2)
unnamed: ATT_5.CW1, IN1R5.P3 (3)
unnamed: ATT_5.CENTER, R11.1
unnamed: ATT_5.CENTER1, R12.1
OUT_L: C5.1, OPAMP_IS.8 (OUT), R17.2, R18.2
OUT_R: C6.1, OPAMP_IS.14 (OUT), R19.2, R20.2
SEND_L: OPAMP_IS.7 (OUT), R13.2, R15.1
SEND_R: OPAMP_IS.1 (OUT), R14.2, R16.1

Notes on the sheet:
In den rechten kann man auch nen stereo plug rein machen.
Dann is verdreht aber naja...
v=4

Parts:
C1: .1u; C0603; MOUSER 710-885012206071
C2: .1u; C0603
C3: 22u; C1210; MOUSER 810-C3225X7R1C226M
C4: 22u; C1210
D2: CGRM4002-G; SOD-123_MINI-SMA; MOUSER 621-B130-F
D3: CGRM4002-G; SOD-123_MINI-SMA
JP1: M05X2SMD; 2X5-SMD; MOUSER 855-M20-8750542
OPAMP_IS: TL074D; SO14; MOUSER 595-TL074IDR

Connections:
GND: C1.2, C2.1, C3.2, C4.1, JP1.3, JP1.4, JP1.5, JP1.6, JP1.7, JP1.8; also elsewhere on the board
unnamed: D2.A, JP1.9, JP1.10
unnamed: D3.C, JP1.1, JP1.2
VDD: C1.1, C3.1, D2.C, OPAMP_IS.4 (V+)
VSS: C2.2, C4.2, D3.A, OPAMP_IS.11 (V-)

Board: 2 copper layers, 109.2 x 39.6 mm, 51 parts (1 on the bottom side), 39 nets.

## Commit log

2020-07-09 Added BOM and Mouser PartNr
2020-07-09 Added some 3D parts, README..
2020-07-09 more README..
2020-07-25 bug fix, feedback in second stage must go to -, GND to + inputs
